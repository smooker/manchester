options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: IF
  id: variable
  parameters:
    value: '470000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '1'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '433920030'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/fifo
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '100'
    init: '0'
    low: '-100'
  states: {state: disabled}
- name: blocks_threshold_ff_1
  id: blocks_threshold_ff
  parameters:
    high: '0.1'
    init: '0'
    low: '0.05'
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: IF
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(2,samp_rate, IF, IF/10)
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: '1'
    gain: '1'
    samp_rate: '384000'
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HANN
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 470000*2
    fc: '0'
    fftsize: '1024'
    name: MAIKATA_2
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: '128'
    fc: '0'
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: '128'
    fc: freq
    fftsize: '1024'
    name: '"1"'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: '20000'
    fc: '2'
    fftsize: '2048'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '480000'
    srate: '48000'
    tr_level: '0.05'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.05'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '1'
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq-IF
    freq_correction: '51'
    gain: '49.6'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_noise_source_x_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [blocks_complex_to_float_0, '0', blocks_threshold_ff_1, '0']
- [blocks_complex_to_float_0, '0', qtgui_sink_x_1, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0, '1']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_1, '0']
- [blocks_null_source_0, '0', audio_sink_0, '1']
- [blocks_null_source_0, '0', blocks_threshold_ff_1, '0']
- [blocks_threshold_ff_1, '0', audio_sink_0, '0']
- [blocks_threshold_ff_1, '0', blocks_file_sink_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', low_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_null_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_sink_x_0_1, '0']

metadata:
  file_format: 1
  grc_version: v3.10.5.1-1-gf972571a
