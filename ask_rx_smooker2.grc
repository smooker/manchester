options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: IF
  id: variable
  parameters:
    value: '470000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '1'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '433900000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/fifo
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '100'
    init: '0'
    low: '-100'
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: IF
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,samp_rate/(2*decim), BW)
    type: ccf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: BW/3
    gain: '1'
    interp: '1'
    samp_rate: '240000'
    type: interp_fir_filter_ccf
    width: BW/2
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '128'
    fc: freq
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '480000'
    srate: '48000'
    tr_delay: '-480'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.05'
    ymin: '-0.1'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    agc: 'True'
    center_freq: freq-IF
    gain: '30'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', audio_sink_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_1, '0', blocks_file_sink_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', low_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_1, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_1, '0']

metadata:
  file_format: 1
  grc_version: v3.10.5.1-1-gf972571a
