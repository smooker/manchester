options:
  parameters:
    generate_options: qt_gui
    id: smooker_am_demod_new
    output_language: python
    title: ASK Receiver
  states: {}

blocks:
- name: audio_squelch
  id: variable_qtgui_range
  parameters:
    start: '-80'
    step: '1'
    stop: '0'
    value: '-30'
  states: {}
- name: decim1
  id: variable
  parameters:
    value: '2'
  states: {}
- name: decim2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: if_freq
  id: variable
  parameters:
    value: '470000'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: '433920000'
  states: {state: disabled}
- name: rf_freq
  id: variable_qtgui_range
  parameters:
    start: '433033000'
    step: '1'
    stop: '434333000'
    value: '433920000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'False'
    ramp: '10'
    threshold: audio_squelch
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1.5'
    offset: '0'
    phase: '0'
    samp_rate: '192000'
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1.5'
    offset: '0'
    phase: '0'
    samp_rate: '192000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '20000'
    low_cutoff_freq: '500'
    samp_rate: '192000'
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {state: bypassed}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: if_freq
    decim: decim1
    samp_rate: samp_rate
    taps: ' firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decim1), samp_rate/(2*decim1), transition_bw)'
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50000'
    decim: '1'
    gain: '2'
    samp_rate: samp_rate/decim1
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: '1'
    gain: '5'
    samp_rate: '192000'
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: samp_rate/decim1/192000
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    size: '409600'
    srate: '192000'
    tr_level: '3'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '100000'
    fc: '0'
    fftsize: '16384'
    grid: 'True'
    int_max: '0'
    int_min: '-80'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '1024000'
    fc: rf_freq-if_freq
    fftsize: '8192'
    grid: 'True'
    int_max: '0'
    int_min: '-80'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '20000'
    fc: '0'
    fftsize: '8192'
    freqhalf: 'False'
    grid: 'True'
    int_max: '0'
    int_min: '-80'
    showports: 'True'
    type: float
    update_time: '0.0001'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: fff
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    bandwidth: '2000000'
    center_freq: rf_freq-if_freq+1000
    gain: '40'
    minoutbuf: '20480'
    samp_rate: samp_rate
    type: fc32
    vga: '40'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: rf_freq-if_freq
    freq_correction: '41'
    gain: '40'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_pwr_squelch_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '0']
- [band_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [blocks_add_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', mmse_resampler_xx_0, '0']
- [low_pass_filter_0_0, '0', band_pass_filter_0, '0']
- [mmse_resampler_xx_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.5.1-1-gf972571a
